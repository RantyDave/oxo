# Keil uVision project oxo.uvprojx, settings and files
target nRF51822AA (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: oxo +hex
  c flags: Optim=1
  c define: ENABLE_DEBUG_LOG_SUPPORT, TARGET_NRF51822,  TARGET_M0,  TARGET_NORDIC,  TARGET_NRF51822_MKIT,  TARGET_MCU_NRF51822,  TOOLCHAIN_ARM_STD,  TOOLCHAIN_ARM,  __CORTEX_M0,  ARM_MATH_CM0,  MBED_BUILD_TIMESTAMP=1409901455.86,  __MBED__=1,  __ASSERT_MSG,
  c misc: --gnu
  c include: .;  nRF51822;  nRF51822/nordic;  nRF51822/nordic/nrf-sdk;  nRF51822/nordic/nrf-sdk/s110;  nRF51822/nordic/nrf-sdk/app_common;  nRF51822/nordic/nrf-sdk/sd_common;  nRF51822/nordic/nrf-sdk/ble;  nRF51822/nordic/nrf-sdk/ble/device_manager;  nRF51822/nordic/nrf-sdk/ble/ble_services;  nRF51822/nordic/app_common;  nRF51822/nordic/ble;  nRF51822/nordic/ble/ble_services;  nRF51822/common;  nRF51822/btle;  nRF51822/btle/custom;  mbed;  mbed/TARGET_NRF51822;  mbed/TARGET_NRF51822/TARGET_NORDIC;  mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822;  mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/TARGET_NRF51822_MKIT;  mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib;  mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/s110_nrf51822_7_0_0;  mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/s110_nrf51822_7_0_0/s110_nrf51822_7.0.0_API;  mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/s110_nrf51822_7_0_0/s110_nrf51822_7.0.0_API/include;  mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD;  BLE_API;  BLE_API/common;  BLE_API/public
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/sys.o
            
              mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/cmsis_nvic.o
            
              mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/startup_nRF51822.o
            
              mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/system_nrf51822.o
            
              mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/board.o
            
              mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/retarget.o
            
              mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/mbed.ar
  group src
    nRF51822/nordic/app_common/: app_scheduler.c hci_mem_pool.c crc16.cpp pstorage.cpp
    nRF51822/: nRF51Gap.cpp nRF51822n.cpp nRF51GattServer.cpp
    nRF51822/nordic/: softdevice_handler.cpp
    nRF51822/nordic/ble/: ble_bondmngr.cpp ble_debug_assert_handler.cpp ble_advdata_parser.cpp ble_conn_params.cpp ble_error_log.cpp ble_advdata.cpp
    nRF51822/nordic/ble/ble_services/: ble_srv_common.cpp
    nRF51822/btle/: btle_gap.cpp btle_advertising.cpp btle.cpp
    BLE_API/common/: GattService.cpp GapAdvertisingData.cpp GapAdvertisingParams.cpp UUID.cpp
    ./nRF51822/nordic/app_common/: app_timer.c app_trace.c
    ./nRF51822/nordic/: simple_uart.c
    ./nRF51822/btle/custom/: custom_helper.cpp
  group oxo
    ./: main.cpp
    ./: oxo_ble_interface.cpp debug.cpp
  group ::Device
    RTE/Device/nRF51822_xxAA/: arm_startup_nrf51.s system_nrf51.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
